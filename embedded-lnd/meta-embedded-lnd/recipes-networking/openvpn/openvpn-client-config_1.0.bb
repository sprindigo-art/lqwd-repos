SUMMARY = "OpenVPN client profile for the lnd appliance"
DESCRIPTION = "Installs rpi.ovpn as /etc/openvpn/client.conf so the device \
joins the management VPN on boot. The profile embeds the client private key, \
so it is read from outside the git tree and installed 0600."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

# Generated by the openvpn container on the build server. NEVER in git - the
# file contains a private key. Override in local.conf if you keep it elsewhere.
VPN_ARTIFACTS_DIR ?= "/vm/testbed/vpn/clients"
FILESEXTRAPATHS:prepend := "${VPN_ARTIFACTS_DIR}:"

SRC_URI = "file://rpi.ovpn"
S = "${WORKDIR}"

# The stock openvpn init script starts every /etc/openvpn/*.conf, so dropping
# the profile in place is all that is needed. tun is a module in the RPi kernel.
RDEPENDS:${PN} = "openvpn kernel-module-tun"

do_install() {
    install -d -m 0700 ${D}${sysconfdir}/openvpn
    install -m 0600 ${WORKDIR}/rpi.ovpn ${D}${sysconfdir}/openvpn/client.conf
}

FILES:${PN} = "${sysconfdir}/openvpn"
CONFFILES:${PN} = "${sysconfdir}/openvpn/client.conf"
